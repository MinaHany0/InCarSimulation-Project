# IAR project AUTOSAR_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: AUTOSAR_Project.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c startup_ewarm.c
  group driverlib
    driverlib/: adc.c adc.h aes.c aes.h can.c can.h comp.c comp.h cpu.c cpu.h crc.c crc.h debug.h des.c des.h eeprom.c eeprom.h emac.c emac.h epi.c epi.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h lcd.c lcd.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h shamd5.c shamd5.h ssi.c ssi.h stdbool.h stdint.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group ecual/CanDriver
    ecual/CanDriver/: CanDriver.c CanDriver.h
  group ecual/DC_motor
    ecual/DC_Motor/: DC_Motor.c DC_Motor.h DC_Motor_cfg.h DC_Motor_priv.h
  group ecual/fan
    ecual/FAN/: FAN.c FAN.h
  group ecual/pwmDriver
    ecual/pwmDriver/: PWM.c PWM_Interface.h
  group inc
    inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_onewire.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c123gh6pm.h
  group library
    library/: common_macros.h Compiler.h Delay_interface.h Delay_Program.c Platform_Types.h Std_Types.h
  group mcal/dio
    mcal/dio/: Dio.c Dio.h Dio_Cfg.h Dio_PBcfg.c Dio_Regs.h
  group mcal/gpt
    mcal/gpt/: Gpt.c Gpt.h
  group mcal/port
    mcal/port/: Port.c Port.h Port_cfg.h Port_PBcfg.c
  group mcal/pwm
    mcal/pwm/: PWM.c PWM.h PWM_cfg.h PWM_priv.h PWM_Types.h
  group service/det
    service/det/: Det.c Det.h
